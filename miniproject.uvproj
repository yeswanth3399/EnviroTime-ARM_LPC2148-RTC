# Keil uVision project miniproject.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARM Compiler 5.06)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: miniproject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s rtc_test.c adc.c lcd.c lm35.c rtc.c kpm.c normal.c menu.c rtc_edit.c alarm.c timer0_delay.c alarm_ring.c
